# Keil uVision project traffic_lights.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: traffic_lights +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: C:\ti\TivaWare_C_Series-2.1.4.178;..\traffic_lights
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ../traffic_lights/: main.c
    ./: basic_io.c basic_io.h
  group driverlib
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 10.2.1, RTOS:Core 10.2.1, RTOS:Heap 10.2.1, CMSIS:CORE 5.3.0, Device:Startup 1.0.0
